# IAR project stm32f030c8_rxtx.ewp, settings and files
configuration stm32f030c8_rxtx (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F030x8
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include; ../Drivers/modbus/ascii; ../Drivers/modbus/functions; ../Drivers/modbus/include; ../Drivers/modbus/port; ../Drivers/modbus/rtu; ../Drivers/modbus/tcp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32f030c8_rxtx.hex
  ILINK.IlinkOutputFile: stm32f030c8_rxtx.out
  ILINK.IlinkIcfFile: stm32f030c8_rxtx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f030x8.s
  group Application/User/Core
    ../Core/Src/: Buttons_menu.c Flash_EEPROM.c kty_81_110.c led.c main.c median.c stm32f0xx_hal_msp.c stm32f0xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group Drivers/modbus
    ../Drivers/modbus/: mb.c
  group Drivers/modbus/ascii
    ../Drivers/modbus/ascii/: mbascii.c mbascii.h
  group Drivers/modbus/functions
    ../Drivers/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Drivers/modbus/port
    ../Drivers/modbus/port/: port.h portevent.c portserial.c porttimer.c
  group Drivers/modbus/rtu
    ../Drivers/modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_exti.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
